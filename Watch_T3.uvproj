# Keil uVision project Watch_T3.uvproj, settings and files
target mbed NXP LPC11U24 (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: Watch_T3
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: E:\fix_checksum.exe "$L@L.bin"
  c flags: Optim=1
  c define: TARGET_LPC11U24,  TARGET_M0,  TARGET_NXP,  TARGET_LPC11UXX,  TARGET_LPC11U24_401,  TOOLCHAIN_ARM_MICRO,  TOOLCHAIN_ARM,  __CORTEX_M0,  ARM_MATH_CM0,  MBED_BUILD_TIMESTAMP=1395038741.41,  __MBED__=1,
  c misc: --gnu
  c include: .;mbed;mbed/TARGET_LPC11U24;mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO;.\DS1337;.\watch_ui;.\Suli_Mbed;.\OLED_128x64_Suli;.\RTC_DS1307_Suli;.\watch_time
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/LPC11U24.sct
  link misc: mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/system_LPC11Uxx.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/sys.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/cmsis_nvic.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/startup_LPC11xx.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/retarget.o
            
              mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_MICRO/mbed.ar
  group src
    ./: main.cpp
    ./Suli_Mbed/: Suli.cpp
    ./OLED_128x64_Suli/: OLED_128x64_Suli.cpp
    ./RTC_DS1307_Suli/: RTC_DS1307_Suli.cpp
    ./watch_time/: watch_time.cpp
    ./watch_ui/: watch_ui.cpp
